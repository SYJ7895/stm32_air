# Keil uVision project newprj.uvprojx, settings and files
target Air (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mainmcu
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  AfterMake: ./pack.exe -t 0 -h 0
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,__BrdConf_SACTV200,_Debug_Conf
  c include: ..\driver;..\lib\inc;..\lib\CMSIS\Include;..\lib\CMSIS\Device\ST\STM32F1xx\Include;..\STM32F10X
  library: MicroLIB
  memory RVCT4: ROM 0x8002200 size 0xde00
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ../App/: main.c
  group driver
    ../driver/: ctrlbsp.c HT1621.c Sact-misc.c systick.c Esp8266.c i2c.c msg_handler.c flash.c Wifi_process.c cpu_trans.c crc8.c crc32.c image_update.c upgrade.c wdog.c
  group lib
    ../lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group bsp
    ../STM32F10X/: stm32f10x_it.c system_stm32f10x.c
    ../startup/: startup_stm32f10x_md.s
